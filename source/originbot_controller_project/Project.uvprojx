# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: originbot_controller_firmware_freertos +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Source\APP;.\STM32F10xLib\inc;.\STM32F10xLib\M3;.\Source\Drive;.\STM32F10xLib\startup;.\STM32F10xLib\Include;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\FreeRTOS;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./Source/APP/: Main.c pid.c app_motion_control.c protocol.c JY901.c
  group DRIVER
    ./Source/Drive/: delay.c UART1.c DIO.c UART3.c adc.c motor.c encoder.c timer.c
  group FWLib
    ./STM32F10xLib/M3/: system_stm32f10x.c
    ./STM32F10xLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_tim.c
    ./STM32F10xLib/startup/: startup_stm32f10x_hd.s
  group FreeRTOS
    ./FreeRTOS/Source/: list.c queue.c tasks.c croutine.c
    ./FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0
